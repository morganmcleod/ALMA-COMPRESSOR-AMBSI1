# Keil uVision project compressor.uvproj, settings and files
target Compressor Monitor (166/167)
  device: C167CR-LM Siemens
  cpu: IRAM (0xF600 - 0xFDFF) XRAM(0xE000-0xE7FF) ICAN(0xE800-0xEFFF) CLOCK(20000000) MOD167
  output: compressors
  group Source
    ./: main.c serial.c
  group Startup
    ./: Start167.a66
  group Libraries
    ../libraries/error/: errorssmall.LIB
    ../libraries/ds1820/: ds1820ambsismall.LIB
    ../libraries/amb/: ambambsismall.LIB
    ../libraries/onboard_adc/: onboard_adcsmall.LIB
target Compressor Flash (166/167)
  device: C167CR-LM Siemens
  cpu: as above
  output: compressorhl +hex
target Compressor Small (166/167)
  device: C167-LM Infineon
  cpu: IRAM(0xF600-0xFDFF) CLOCK(20000000) MOD167
  output: compressorSmall +hex
